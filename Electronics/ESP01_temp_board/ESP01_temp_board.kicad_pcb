# Repository Vedatori/SleetClock

File README.md:

# SleetClock [cz]
SleetClock je otevřená platforma chytré meteostanice vyvinutá jako projekt pro výuku elektroniky a programování. Ve fázi návrhu byl kladen důraz na jednoduchou a levnou výrobu s vysokou užitnou hodnotou výsledného výrobku v každé domácnosti.

SleetClock byl vyvinut jako hlavní výrobek letního technického tábora 2019 v Chotěborkách pořádaným spolkem Vědátoři.
Do vývojového týmu patří Martin Ptáček, Martin Coufal, Marek Coufal a Petr Vávra z Brna.

Meteostanice je založena na 3D tištěném a laserem vyřezávaném překližkovém šasi. Srdcem výrobku je vývojový kit ESP32, který se stará o vyčítání hodnot ze senzorů, bezdrátovou komunikaci, ovládání LED symbolů počasí a o vykreslování na grafické obrazovce.

SleetClock se vyznačuje:
* Nokia 84x48 LCD grafická orbrazovka
* ESP32 MCU s podporou WiFi & Bluetooth
* Integrovaný a externí teplotní senzor
* LED indikátor počasí
* Rotační ovládací prvek, potenciometr, tlačítka a dotykové ovládání

Chceš si sestavit vlastní SleetClock? Přesuň se do sekce [návody](Manuals) a postupuj v pořadí:
1. [Elektronika](Manuals/SleetClock_electronics_cz.md)
1. [Mechanika](Manuals/SleetClock_mechanics_cz.md)
1. [Dotykový senzor](Manuals/SleetClock_touchSensor_cz.md)

## Licence
* Obsah tohoto repozitáře mimo složku *Software* je sdílen pod licencí [Attribution-NonCommercial-ShareAlike 4.0 International (CC BY-NC-SA 4.0)](https://creativecommons.org/licenses/by-nc-sa/4.0/).
* Obsah složky *Software* je sdílen pod licencí [GNU Lesser General Public License v3.0](https://www.gnu.org/licenses/lgpl-3.0.en.html).

# SleetClock [en]
SleetClock is an open-source weather station platform developed as a support for electronics and programming education. In construction emhasis was placed on easy and low-cost fabrication with a broad utilization of final product in any household.

SleetClock was developed to be the main technical project in Chotěborky 2019 Summer Camp organised by the Vědátoři society.
The developer team includes Martin Ptacek, Martin Coufal, Marek Coufal & Petr Vavra from Brno, Czech Republic.

The meteostation is based on a semi 3D-printed and plywood laser cutted chassis. SleetClock is powered by the ESP32 MCU dev kit, which takes care of reading sensor data, wireless communication, controlling the LED weather symbols and the graphical display.

The main features of SleetClock include:
* Nokia 84x48 LCD graphical display
* ESP32 MCU that enables wireless communication via WiFi & Bluetooth
* On-board & external temperature sensor
* LED weather indicator
* Rotary encoder, potentiometer, buttons & touch user control

Ready to assemble your own SleetClock? All manuals use czech descriptions so we advice using the translated version of the site. Head to section [Manuals](Manuals) and proceed in order:
1. [Electronics](Manuals/SleetClock_electronics_cz.md)
1. [Mechanics](Manuals/SleetClock_mechanics_cz.md)
1. [Touch sensor](Manuals/SleetClock_touchSensor_cz.md)

## License
* The contents of this repository excluding folder *Software* is shared under license [Attribution-NonCommercial-ShareAlike 4.0 International (CC BY-NC-SA 4.0)](https://creativecommons.org/licenses/by-nc-sa/4.0/).
* The contents of the folder *Software* is shared under license [GNU Lesser General Public License v3.0](https://www.gnu.org/licenses/lgpl-3.0.en.html).

Základní schéma zapojení / Schematic general:\

Schéma zapojení LED PWM ovladače / Schematic LED PWM driver:\

Navržená deska plošných spojů / Routed board:\

Realizace PCB a vnitřní část šasi / Realization of PCB and inside the chassis:\

## KiCad design Electronics/ESP01_temp_board/ESP01_temp_board.kicad_pcb

Parts:
C1: 10uF; CP_Radial_D5.0mm_P2.00mm
C2: 22uF; CP_Radial_D5.0mm_P2.00mm
D1: LM5819; D_MiniMELF
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Power_connector; TerminalBlock_bornier-2_P5.08mm
J2: Flash_connector; PinSocket_1x04_P2.54mm_Vertical
R1, R2: 330R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R3, R4, R5, R6: 4K7; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1: RESET; SW_PUSH_6mm
SW2: FLASH; SW_PUSH_6mm
U1: ESP-01v090; ESP-01
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: DS18B20; TO-92_Inline_Wide
U4: DHT11; Aosong_DHT11_5.5x12.0_P2.54mm

Connections:
+3V3: C2.1, R3.1, R4.1, R5.1, R6.1, U1.7 (VCC), U2.2 (VO), U3.3 (VDD), U4.1 (VCC)
+5V: C1.1, D1.1 (K), U2.3 (VI)
GND: C1.2, C2.2, J1.1, J2.1, SW1.1, SW2.1, U1.2 (GND), U2.1 (GND), U3.1 (GND), U4.4 (GND)
unnamed: D1.2 (A), J1.2, J2.4
unnamed: J2.2, R2.1
unnamed: J2.3, R1.1
unnamed: R1.2, U1.1 (UTXD)
unnamed: R2.2, U1.8 (URXD)
unnamed: R3.2, SW1.2, U1.5 (RST)
unnamed: R4.2, U1.3 (CH_PD)
unnamed: R5.2, U1.4 (GPIO2), U3.2 (DQ), U4.2 (IO)
unnamed: R6.2, SW2.2, U1.6 (GPIO0)

Board: 2 copper layers, 68.0 x 20.0 mm, 20 parts (1 on the bottom side), 12 nets.

Other parts of the board:
.: .; Vedatori_18mm

## KiCad design Electronics/ESP32 dev board/ESP32 dev board.kicad_pcb

Parts:
C1, C2, C4, C6: 220nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3, C5: 100uF; CP_Radial_D6.3mm_P2.50mm
D1: Nokia_5110_TZT_display
ENC1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Touch_sensors; PinSocket_1x07_P2.54mm_Vertical
J2: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
J9: RESET; PinHeader_1x02_P2.54mm_Vertical
J10: ESP-01_program; PinSocket_1x04_P2.54mm_Vertical
POT1: R_POT; Potentiometer_Alps_RK09K_Single_Vertical
R1: R_PHOTO; R_LDR_5.0x4.1mm_P3mm_Vertical
R2, R3, R4, R5, R7, R8: 10k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R20: 4k7; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1, SW2: SW_Push; SW_PUSH_6mm_H13mm
U1: DS18B20; TO-92_Inline_Wide
U2: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D
U4: DHT11; Aosong_DHT11_5.5x12.0_P2.54mm

Connections:
+3V3: C3.1, C4.1, D1.6, ENC1.S1, POT1.1, R1.2, R3.2, R5.2, R20.2, SW1.2, SW2.2, U1.3 (VDD), U2.1 (3V3), U4.1 (VCC); also elsewhere on the board
+5V: C5.1, C6.1, J10.1, U2.19 (EXT_5V); also elsewhere on the board
BL: D1.7; also elsewhere on the board
CE: D1.2, U2.29 (IO5)
CLK: D1.5, U2.21 (IO23)
DC: D1.3, U2.28 (IO18)
DIN: D1.4, U2.27 (IO19)
EN: J9.2, U2.2 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.8, ENC1.C, J9.1, J10.4, POT1.3, R2.1, R4.2, R7.2, R8.2, U1.1 (GND), U2.14 (GND1), U2.20 (GND3), U2.26 (GND2), U4.4 (GND); also elsewhere on the board
RST: D1.1, U2.7 (IO32)
RX: J10.2, U2.24 (RXD0)
SCL: U2.22 (IO22); also elsewhere on the board
SDA: U2.25 (IO21); also elsewhere on the board
TX: J10.3, U2.23 (TXD0)
button0: R7.1, SW1.1, U2.3 (SENSOR_VP)
button1: R8.1, SW2.1, U2.4 (SENSOR_VN)
encoderA: C1.1, ENC1.B, R3.1, U2.9 (IO25)
encoderB: C2.1, ENC1.A, R5.1, U2.10 (IO26)
encoderSwitch: ENC1.S2, R4.1, U2.30 (IO17)
photoresistor: R1.1, R2.2, U2.6 (IO35)
potentiometer: POT1.2, U2.5 (IO34)
tempData: R20.1, U1.2 (DQ), U2.31 (IO16), U4.2 (IO)
touch0: J1.1, U2.32 (IO4)
touch1: J2.1, U2.33 (IO0)
touch2: J2.2, U2.34 (IO2)
touch3: J1.2, U2.35 (IO15)
touch4: J1.3, U2.15 (IO13)
touch5: J1.4, U2.13 (IO12)
touch6: J1.5, U2.12 (IO14)
touch7: J1.6, U2.11 (IO27)
touch8: J1.7, U2.8 (IO33)

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13: LED; LED_D3.0mm
D14: LED_RCGB; LED_D5.0mm-4_RGB_Wide_Pins
Q1, Q2, Q3, Q4: BC547; TO-92_Inline_Wide
R6, R9, R10, R11: 22k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R12, R13, R14, R15: 51R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R16, R17: 1k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R18, R19, R21: 330R; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
S0: servo0; PinHeader_1x03_P2.54mm_Vertical
S1: servo1; PinHeader_1x03_P2.54mm_Vertical
S2: servo2; PinHeader_1x03_P2.54mm_Vertical
S3: servo3; PinHeader_1x03_P2.54mm_Vertical
S4: servo4; PinHeader_1x03_P2.54mm_Vertical
S5: servo5; PinHeader_1x03_P2.54mm_Vertical
S6: servo6; PinHeader_1x03_P2.54mm_Vertical
U3: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm

Connections:
+3V3: R16.1, R17.1, U3.28 (VDD); also elsewhere on the board
+5V: D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), S0.2, S1.2, S2.2, S3.2, S4.2, S5.2, S6.2; also elsewhere on the board
BL: U3.13 (LED7); also elsewhere on the board
GND: BZ1.2 (+), D14.2 (K), Q1.3 (E), Q2.3 (E), Q3.3 (E), Q4.3 (E), S0.3, S1.3, S2.3, S3.3, S4.3, S5.3, S6.3, U3.1 (A0), U3.2 (A1), U3.3 (A2), U3.4 (A3), U3.5 (A4), U3.14 (VSS), U3.23 (~OE), U3.24 (A5), U3.25 (EXTCLK); also elsewhere on the board
unnamed: D3.1 (K), D4.1 (K), D5.1 (K), R13.1
unnamed: D6.1 (K), D7.1 (K), D8.1 (K), R15.1
unnamed: D9.1 (K), D10.1 (K), D11.1 (K), R14.1
unnamed: D2.1 (K), D12.1 (K), D13.1 (K), R12.1
unnamed: D14.1 (RA), R18.1
unnamed: D14.3 (GA), R19.1
unnamed: D14.4 (BA), R21.1
unnamed: Q1.1 (C), R12.2
unnamed: Q1.2 (B), R6.1
unnamed: Q2.1 (C), R13.2
unnamed: Q2.2 (B), R9.1
unnamed: Q3.1 (C), R14.2
unnamed: Q3.2 (B), R10.1
unnamed: Q4.1 (C), R15.2
unnamed: Q4.2 (B), R11.1
SCL: R17.2, U3.26 (SCL); also elsewhere on the board
SDA: R16.2, U3.27 (SDA); also elsewhere on the board
buzzer: BZ1.1 (-), U3.15 (LED8)
cloudLED: R6.2, U3.9 (LED3)
dropsLED: R9.2, U3.8 (LED2)
flakesLED: R10.2, U3.7 (LED1)
lightningLED: R11.2, U3.6 (LED0)
rgbB: R21.2, U3.12 (LED6)
rgbG: R19.2, U3.11 (LED5)
rgbR: R18.2, U3.10 (LED4)
servo0: S0.1, U3.16 (LED9)
servo1: S1.1, U3.17 (LED10)
servo2: S2.1, U3.18 (LED11)
servo3: S3.1, U3.19 (LED12)
servo4: S4.1, U3.20 (LED13)
servo5: S5.1, U3.21 (LED14)
servo6: S6.1, U3.22 (LED15)

Board: 2 copper layers, 100.0 x 75.0 mm, 70 parts (26 on the bottom side), 61 nets.

Other parts of the board:
.: .; Vedatori_18mm

## Commit log

2021-03-19 Initial commit. General repository update.
